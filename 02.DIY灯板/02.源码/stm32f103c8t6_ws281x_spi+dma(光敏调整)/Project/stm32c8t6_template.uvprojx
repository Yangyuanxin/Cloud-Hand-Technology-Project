# Keil uVision project stm32c8t6_template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32c8t6_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Chip\chip;..\Chip\delay;..\Chip\timer;..\Chip\usart;..\Chip\spi;..\User;..\Board\HC-SR501;..\Board\photoresistor;..\Board\key;..\Board\key_detect;..\Board\public;..\Board\RGB_Dispose;..\Board\Lsens
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STFWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CHIP
    ../Chip/chip/: chip.c
    ../Chip/delay/: delay.c
    ../Chip/timer/: timer.c
    ../Chip/usart/: usart.c
  group BOARD
    ../Board/ws2812/: ws2812.c
    ../Board/key/: key.c
    ../Board/key_detect/: key_detect.c
    ../Board/public/: public.c
    ../Board/RGB_Dispose/: RGB_Dispose.c
    ../Board/Lsens/: Lsens.c
  group USER
    ../User/: main.c stm32f10x_it.c
